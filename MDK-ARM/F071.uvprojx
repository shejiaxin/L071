# Keil uVision project F071.uvprojx, settings and files
target F071 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L071RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: F071 +hex
  AfterMake: ./keil5_disp_size_bar
  AfterMake: fromelf.exe --bin -o ../MDK-ARM/@L_emg.bin ../MDK-ARM/F071/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32L071xx
  c include: ../Core/Inc;  ../Drivers/STM32L0xx_HAL_Driver/Inc;  ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;  ../Drivers/CMSIS/Include;  ..\User\lora;  ..\MDK-ARM;  ..\User\lora;  ..\User\ec800;  ..\User\user_iic;  ..\User\stop;  ..\User\modbus_crc;  ..\User\user_usart;  ..\User\mem;  ..\BSP\inc;  ..\BSP\inc\template;  ..\RTT\config;  ..\RTT;  ..\User\json
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x20000
  memory RVCT9: RAM 0x20000008 size 0x5000
  memory RVCT10: RAM 0x20000000 size 0x8
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c usart.c rtc.c tim.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group User
    ./: include.h
    ../User/ec800/: ec800.c control.c ConfigModuleNoBlock.c
    ../User/user_iic/: user_iic.c
    ../User/stop/: stop.c
    ../User/modbus_crc/: modbus_crc.c
    ../User/user_usart/: user_usart.c
  group BSP
    ../User/mem/: BufferManage.c LoopList.c
    ../BSP/src/: bsp_board.c bsp_key.c bsp_timer.c
    ../RTT/: log.h
    ../User/json/: cJSON.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
